options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rfnoc_ddc
    output_language: python
  states: {}

blocks:
- name: device3
  id: variable_uhd_device3
  parameters:
    dev_addr: type=x300
    dev_args: '""'
  states: {}
- name: master_clock_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: RX Frequency
    orient: Qt.Horizontal
    start: 50e6
    step: 1e6
    stop: 6e9
    value: 2.45e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_rfnoc_digital_gain_0
  id: uhd_rfnoc_digital_gain
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_digital_gain
    gain: '1.0'
    grvlen: '1'
  states: {}
- name: uhd_rfnoc_fosphor_display_0
  id: uhd_rfnoc_fosphor_display
  parameters:
    center_freq: '0'
    fft_bins: '1024'
    frame_rate: '30'
    grid_enabled: 'True'
    palette: iron
    pwr_bins: '64'
    samp_rate: samp_rate
    wf_enabled: 'True'
    wf_lines: '512'
  states: {}
- name: uhd_rfnoc_pdu_rx_0
  id: uhd_rfnoc_pdu_rx
  parameters:
    block_index: '-1'
    device_index: '-1'
    grvlen: '1'
    mtu: '2048'
    otw_format: sc16
    type: fc32
  states: {}
- name: uhd_rfnoc_pdu_tx_0
  id: uhd_rfnoc_pdu_tx
  parameters:
    block_index: '-1'
    device_index: '-1'
    grvlen: '1'
    otw_format: sc16
    type: fc32
  states: {}
- name: uhd_rfnoc_pdu_tx_0_0
  id: uhd_rfnoc_pdu_tx
  parameters:
    block_index: '-1'
    device_index: '-1'
    grvlen: '1'
    otw_format: sc16
    type: fc32
  states: {}
- name: uhd_rfnoc_pdu_tx_0_1
  id: uhd_rfnoc_pdu_tx
  parameters:
    block_index: '-1'
    device_index: '-1'
    grvlen: '1'
    otw_format: sc16
    type: fc32
  states: {}
- name: uhd_rfnoc_pdu_tx_1
  id: uhd_rfnoc_pdu_tx
  parameters:
    block_index: '-1'
    device_index: '-1'
    grvlen: '1024'
    otw_format: sc16
    type: fc32
  states: {}
- name: uhd_rfnoc_register_probe_0
  id: uhd_rfnoc_register_probe
  parameters:
    block_id: rfnoc_block_0
    logger_id: rfnoc_register_logger_0
    registers: '["reg0","reg1"]'
  states: {}
- name: uhd_rfnoc_streamer_adder_0
  id: uhd_rfnoc_streamer_adder
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_addsub
    type: fc32
  states: {}
- name: uhd_rfnoc_streamer_debug_0
  id: uhd_rfnoc_streamer_debug
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_debug
    null_sink: '1'
    null_src: '1'
    spp: '64'
  states: {}
- name: uhd_rfnoc_streamer_dma_fifo_0
  id: uhd_rfnoc_streamer_dma_fifo
  parameters:
    base_addr_0: '0'
    base_addr_1: '33554432'
    block_index: '-1'
    depth_0: '33554432'
    depth_1: '33554432'
    device_index: '-1'
    fpga_module_name: noc_block_axi_dma_fifo
    grvlen: '1'
    num_chans: '1'
    otw: sc16
    type: fc32
  states: {}
- name: uhd_rfnoc_streamer_fft_0
  id: uhd_rfnoc_streamer_fft
  parameters:
    block_index: '-1'
    device_index: '-1'
    direction: '"forward"'
    fft_size: '256'
    fpga_module_name: noc_block_fft
    magnitude_out: '"COMPLEX"'
    scaling: '1706'
    shift: '"normal"'
  states: {}
- name: uhd_rfnoc_streamer_fifo_0
  id: uhd_rfnoc_streamer_fifo
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_axi_fifo_loopback
    grvlen: '1'
    otw: sc16
    type: fc32
  states: {}
- name: uhd_rfnoc_streamer_fosphor_0
  id: uhd_rfnoc_streamer_fosphor
  parameters:
    alpha: '65280'
    block_index: '-1'
    device_index: '-1'
    epsilon: '1'
    fft_size: '1024'
    fpga_module_name: noc_block_fosphor
    hist_decim: '1'
    offset: '0'
    scale: '256'
    tdecay: '16384'
    trise: '4096'
    wf_decim: '16'
    wf_mode: '-1'
  states: {}
- name: uhd_rfnoc_streamer_keep_one_in_n_0
  id: uhd_rfnoc_streamer_keep_one_in_n
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_keep_one_in_n
    n: '100'
    vlen: '256'
  states: {}
- name: uhd_rfnoc_streamer_logpwr_0
  id: uhd_rfnoc_streamer_logpwr
  parameters:
    block_index: '-1'
    device_index: '-1'
    fpga_module_name: noc_block_logpwr
    grvlen: '1'
    type: fc32
  states: {}
- name: uhd_rfnoc_streamer_radio_0
  id: uhd_rfnoc_streamer_radio
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    cpu_format: fc32
    dcenable0: 'True'
    dcenable1: 'True'
    device_index: '-1'
    direction: tx
    freq0: 1.982e9
    freq1: 1.982e9
    gain0: '20'
    gain1: '20'
    grvlen: '256'
    hide_lo_controls: 'True'
    lo_export0: 'False'
    lo_export1: 'False'
    lo_source0: '"internal"'
    lo_source1: '"internal"'
    num_channels: '1'
    otw_format: sc16
    radio_index: '0'
    rate: samp_rate
    rx_bandwidth0: 56e6
    rx_bandwidth1: 56e6
    source: '"internal"'
    stream_args: ''
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_rfnoc_digital_gain_0, '0', uhd_rfnoc_streamer_fifo_0, '0']
- [uhd_rfnoc_pdu_tx_0, '0', uhd_rfnoc_pdu_rx_0, '0']
- [uhd_rfnoc_pdu_tx_0_0, '0', uhd_rfnoc_streamer_logpwr_0, '0']
- [uhd_rfnoc_pdu_tx_0_1, '0', uhd_rfnoc_streamer_dma_fifo_0, '0']
- [uhd_rfnoc_pdu_tx_1, '0', uhd_rfnoc_streamer_fosphor_0, '0']
- [uhd_rfnoc_streamer_adder_0, '0', uhd_rfnoc_digital_gain_0, '0']
- [uhd_rfnoc_streamer_debug_0, '0', uhd_rfnoc_streamer_adder_0, '1']
- [uhd_rfnoc_streamer_debug_0, '1', qtgui_histogram_sink_x_0, '0']
- [uhd_rfnoc_streamer_dma_fifo_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [uhd_rfnoc_streamer_fft_0, '0', uhd_rfnoc_streamer_keep_one_in_n_0, '0']
- [uhd_rfnoc_streamer_fifo_0, '0', blocks_throttle_0, '0']
- [uhd_rfnoc_streamer_fosphor_0, '0', uhd_rfnoc_fosphor_display_0, '0']
- [uhd_rfnoc_streamer_fosphor_0, '1', uhd_rfnoc_fosphor_display_0, '1']
- [uhd_rfnoc_streamer_keep_one_in_n_0, '0', uhd_rfnoc_streamer_debug_0, '0']
- [uhd_rfnoc_streamer_logpwr_0, '0', uhd_rfnoc_streamer_adder_0, '0']
- [uhd_rfnoc_streamer_radio_0, '0', uhd_rfnoc_streamer_fft_0, '0']

metadata:
  file_format: 1
